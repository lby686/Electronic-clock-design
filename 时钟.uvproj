# Keil uVision project 时钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 时钟 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    C:/Users/lby68/Desktop/单片机实验系统/单片机实验系统/MCU-51-AT89S52-V8.1/PROJECT/Project_C/EXP2_IO驱动实验/P_PROTEUS/AT89C52/: main.c
